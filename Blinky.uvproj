# Keil uVision project Blinky.uvproj, settings and files
target LPC1768 Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: __IRQ_ADC
  c misc: --diag_suppress 550
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./: system_LPC17xx.c
  group Core Code
    ./: core_cm3.c
  group Source Code
    ./: Blinky.c IRQ.c GLCD_SPI_LPC1700.c LED.c KBD.c ADC.h KBD.h ADC.c
  group Pictures
    ./: Bg_16bpp_t.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_b.c ARM_Ani_16bpp.c grug.c hank.c lory.c music_note.c
  group Documentation
    ./: Abstract.txt
